SUMMARY = "A collection of cache libraries in the same API interface. Extracted from werkzeug."

HOMEPAGE = "https://pypi.org/project/cachelib/"

LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a32a7594742a04098377c0c777ec1af7"
SRC_URI[sha256sum] = "47e95a67d68c729cbad63285a790a06f0e0d27d71624c6e44c1ec3456bb4476f"

inherit pypi setuptools3
