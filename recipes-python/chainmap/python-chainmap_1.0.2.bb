inherit pypi setuptools
require python-chainmap.inc

