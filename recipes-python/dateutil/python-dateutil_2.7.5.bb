inherit setuptools
require python-dateutil.inc

SRC_URI[md5sum] = "6357f8f42cbe0e0e0b1e543f3aad07b7"
SRC_URI[sha256sum] = "88f9287c0174266bb0d8cedd395cfba9c58e87e5ad86b2ce58859bc11be3cf02"
