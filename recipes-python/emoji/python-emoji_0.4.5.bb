SUMMARY = "Emoji for Python"
HOMEPAGE = "https://github.com/carpedm20/emoji/"
LICENSE = "BSD"
SECTION = "devel/python"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=9d99980d85e5f81e38ee21f7f4f730d4"

SRC_URI[md5sum] = "5dce7cf156a4980d38300974af4da628"
SRC_URI[sha256sum] = "d8bc4a528b0584b755cc160d98a8e6169d4896f2a5be8a964815517ae7ab298e"

inherit setuptools pypi

