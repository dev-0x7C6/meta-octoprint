SUMMARY = "Emoji for Python"
HOMEPAGE = "https://github.com/carpedm20/emoji/"
LICENSE = "BSD"
SECTION = "devel/python"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=9d99980d85e5f81e38ee21f7f4f730d4"

SRC_URI[md5sum] = "be29f690b59727c345d0648270c78e7e"
SRC_URI[sha256sum] = "a9e9c08be9907c0042212c86dfbea0f61f78e9897d4df41a1d6307017763ad3e"

inherit setuptools pypi

