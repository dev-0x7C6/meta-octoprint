SUMMARY = "Emoji for Python"
HOMEPAGE = "https://pypi.org/project/emoji/"

LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=9d99980d85e5f81e38ee21f7f4f730d4"
SRC_URI[sha256sum] = "60652d3a2dcee5b8af8acb097c31776fb6d808027aeb7221830f72cdafefc174"

inherit pypi setuptools3

