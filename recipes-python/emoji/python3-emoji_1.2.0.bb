SUMMARY = "Emoji for Python"
HOMEPAGE = "https://pypi.org/project/emoji/"

LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=9d99980d85e5f81e38ee21f7f4f730d4"

SRC_URI[sha256sum] = "496f432058567985838c13d67dde84ca081614a8286c0b9cdc7d63dfa89d51a3"

inherit pypi setuptools3

