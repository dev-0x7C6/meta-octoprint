SUMMARY = "Identity management for Flask."
HOMEPAGE = "http://packages.python.org/Flask-Principal/"

PYPI_PACKAGE = "Flask-Principal"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=6acc4c7d4c1d97660292184f4f01522f"
SRC_URI[sha256sum] = "f5d6134b5caebfdbb86f32d56d18ee44b080876a27269560a96ea35f75c99453"

inherit pypi setuptools3
