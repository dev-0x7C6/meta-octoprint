SUMMARY = "Various helpers to pass trusted data to untrusted environments"
HOMEPAGE = "http://packages.python.org/itsdangerous/"

LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.rst;md5=370799bf709a1e4a6a369fa089ac73a6"
SRC_URI[sha256sum] = "321b033d07f2a4136d3ec762eac9f16a10ccd60f53c0c91af90217ace7ba1f19"

inherit pypi setuptools3
