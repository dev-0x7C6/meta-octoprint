require python-netifaces.inc

inherit setuptools

SRC_URI[md5sum] = "e0cfd6c38b39f3ea3185fa7503a81765"
SRC_URI[sha256sum] = "bd590fcb75421537d4149825e1e63cca225fd47dad861710c46bd1cb329d8cbd"
