SUMMARY = "The File Check plugin tries to detect common issues in uploaded files."
HOMEPAGE = "https://pypi.org/project/OctoPrint-FileCheck"

PYPI_PACKAGE = "OctoPrint-FileCheck"

LICENSE = "AGPL-3.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=73f1eb20517c55bf9493b7dd6e480788"
SRC_URI[sha256sum] = "1b2b43386cb07d36e06891098766ec5cc9b5284fd9b5a21dd838a9bea1d9fb2d"

inherit pypi setuptools3
