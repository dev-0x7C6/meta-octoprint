SUMMARY = "The Firmware Check plugin tries to identify printers."
HOMEPAGE = "https://pypi.org/project/OctoPrint-FirmwareCheck/"

PYPI_PACKAGE = "OctoPrint-FirmwareCheck"

LICENSE = "AGPL-3.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=73f1eb20517c55bf9493b7dd6e480788"
SRC_URI[sha256sum] = "b8e90c86af8efe6be4b07f2dd3d5ff9bb308c2ce81afe6ba7e5d56531addeabc"

inherit pypi setuptools3
