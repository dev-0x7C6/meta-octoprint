SUMMARY = "Pattern matching and various utilities for file systems paths."

HOMEPAGE = "https://pypi.python.org/pypi/pkginfo/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=8227180126797a0148f94f483f3e1489"

SRC_URI[sha256sum] = "029a70cb45c6171c329dfc890cde0879f8c52d6f3922794796e06f577bb03db4"

inherit pypi setuptools3
