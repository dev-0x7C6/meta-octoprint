inherit pypi setuptools
require python-psutil.inc

SRC_URI[md5sum] = "0f08bf02400f81c28c4581619ca3e6cb"
SRC_URI[sha256sum] = "6e265c8f3da00b015d24b842bfeb111f856b13d24f2c57036582568dc650d6c3"

