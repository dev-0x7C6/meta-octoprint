inherit setuptools
require python-scandir.inc

SRCREV = "e801b7f76cc3d81c247595bbae8623c7067e0357"

