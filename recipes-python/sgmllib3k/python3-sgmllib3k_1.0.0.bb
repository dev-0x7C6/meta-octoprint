SUMMARY = "Sgmllib for Python 3."
HOMEPAGE = "https://pypi.python.org/pypi/sgmllib3k"

LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=df401240ef196247c2a016b94afa80f8"
SRC_URI[sha256sum] = "7868fb1c8bfa764c1ac563d3cf369c381d1325d36124933a726f29fcdaa812e9"

inherit pypi setuptools3
