SUMMARY = "Filesystem events monitoring"
HOMEPAGE = "https://pypi.org/project/watchdog"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57"
SRC_URI[sha256sum] = "e38bffc89b15bafe2a131f0e1c74924cf07dcec020c2e0a26cccd208831fcd43"

inherit pypi setuptools3
