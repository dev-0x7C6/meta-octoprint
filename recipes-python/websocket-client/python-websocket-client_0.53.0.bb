SUMMARY = "WebSocket client for python. hybi13 is supported."
HOMEPAGE = "https://github.com/websocket-client/websocket-client.git"
LICENSE = "LGPL-3.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=18b09a20dd186af4fd60f1a08311628c"

inherit pypi setuptools

PYPI_PACKAGE = "websocket_client"

SRC_URI[md5sum] = "f1cf4cc7869ef97a98e5f4be25c30986"
SRC_URI[sha256sum] = "40ac14a0c54e14d22809a5c8d553de5a2ae45de3c60105fae53bcb281b3fe6fb"
