SUMMARY = "Werkzeug is a WSGI utility library for Python. It's widely used and BSD licensed."
HOMEPAGE = "http://werkzeug.pocoo.org/"

PYPI_PACKAGE = "Werkzeug"

LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.rst;md5=5dc88300786f1c214c1e9827a5229462"
SRC_URI[sha256sum] = "6c80b1e5ad3665290ea39320b91e1be1e0d5f60652b964a3070216de83d2e47c"

inherit pypi setuptools3
