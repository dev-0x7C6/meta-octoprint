SUMMARY = "A least recently used (LRU) cache implementation"
SECTION = "devel/python"

HOMEPAGE = "https://pypi.python.org/pypi/zeroconf/"

LICENSE = "LGPL-2.1"
LIC_FILES_CHKSUM = "file://COPYING;md5=27818cd7fd83877a8e3ef82b82798ef4"

SRC_URI[sha256sum] = "893a841445663e0c4c20d1111ce41484bd62d58f59d653d0485187343368ef4a"

inherit pypi setuptools3
